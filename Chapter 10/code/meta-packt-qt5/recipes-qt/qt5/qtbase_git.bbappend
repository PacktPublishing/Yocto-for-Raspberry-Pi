COMPATIBLE_MACHINE = "(raspberrypi|raspberrypi0|raspberrypi2|raspberrypi3)"

PACKAGECONFIG_GL = "gles2"
